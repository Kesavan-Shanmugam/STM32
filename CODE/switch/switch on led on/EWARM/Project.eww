<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\switch on led on.ewp</path>
  </project>
  <batchBuild />
</workspace>
